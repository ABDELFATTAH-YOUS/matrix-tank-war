#include "TextManager.h"

// 5x7 font: 5 columns per letter, bit 0 = top row.
// Row 0 = space, rows 1-26 = A-Z, rows 27-36 = 0-9.
static const byte font5x7[37][5] = {
  {0x00,0x00,0x00,0x00,0x00}, // space
  {0x7e,0x11,0x11,0x11,0x7e}, // A
  {0x7f,0x49,0x49,0x49,0x36}, // B
  {0x3e,0x41,0x41,0x41,0x22}, // C
  {0x7f,0x41,0x41,0x22,0x1c}, // D
  {0x7f,0x49,0x49,0x49,0x41}, // E
  {0x7f,0x09,0x09,0x09,0x01}, // F
  {0x3e,0x41,0x49,0x49,0x7a}, // G
  {0x7f,0x08,0x08,0x08,0x7f}, // H
  {0x00,0x41,0x7f,0x41,0x00}, // I
  {0x20,0x40,0x41,0x3f,0x01}, // J
  {0x7f,0x08,0x14,0x22,0x41}, // K
  {0x7f,0x40,0x40,0x40,0x40}, // L
  {0x7f,0x02,0x0c,0x02,0x7f}, // M
  {0x7f,0x04,0x08,0x10,0x7f}, // N
  {0x3e,0x41,0x41,0x41,0x3e}, // O
  {0x7f,0x09,0x09,0x09,0x06}, // P
  {0x3e,0x41,0x51,0x21,0x5e}, // Q
  {0x7f,0x09,0x19,0x29,0x46}, // R
  {0x46,0x49,0x49,0x49,0x31}, // S
  {0x01,0x01,0x7f,0x01,0x01}, // T
  {0x3f,0x40,0x40,0x40,0x3f}, // U
  {0x1f,0x20,0x40,0x20,0x1f}, // V
  {0x3f,0x40,0x38,0x40,0x3f}, // W
  {0x63,0x14,0x08,0x14,0x63}, // X
  {0x07,0x08,0x70,0x08,0x07}, // Y
  {0x61,0x51,0x49,0x45,0x43}, // Z
  {0x3e,0x51,0x49,0x45,0x3e}, // 0
  {0x00,0x42,0x7f,0x40,0x00}, // 1
  {0x42,0x61,0x51,0x49,0x46}, // 2
  {0x21,0x41,0x45,0x4b,0x31}, // 3
  {0x18,0x14,0x12,0x7f,0x10}, // 4
  {0x27,0x45,0x45,0x45,0x39}, // 5
  {0x3c,0x4a,0x49,0x49,0x30}, // 6
  {0x01,0x71,0x09,0x05,0x03}, // 7
  {0x36,0x49,0x49,0x49,0x36}, // 8
  {0x06,0x49,0x49,0x29,0x1e}  // 9
};

TextManager::TextManager() {
    active = false;
    yPos = 32;
}

// Start scrolling `text` from just below the screen
void TextManager::startScroll(String text, int speed) {
    currentText = text;
    currentText.toUpperCase();
    yPos = 32;
    scrollSpeed = speed;
    lastScrollTime = millis();
    active = true;
}

// Map a character to its row in font5x7 (unknown characters -> space)
int getCharIndex(char c) {
    if (c >= 'A' && c <= 'Z') return c - 'A' + 1;
    if (c >= '0' && c <= '9') return c - '0' + 27;
    return 0;
}

// Draw one letter with its top-left corner at (x, y)
void TextManager::drawChar(DisplayManager &display, int x, int y, char c) {
    int idx = getCharIndex(c);
    for (int i = 0; i < 5; i++) {
        byte col = font5x7[idx][i];
        for (int j = 0; j < 7; j++) {
            if (col & (1 << j)) {
                display.setPixel(x + i, y + j, true);
            }
        }
    }
}

// Move the text up one pixel every scrollSpeed ms and redraw it.
// Returns false when the whole text has left the top of the screen.
bool TextManager::update(DisplayManager &display, InputManager &input) {
    if (!active) return false;

    if (input.isTimePassed(lastScrollTime, scrollSpeed)) {
        yPos--;
        lastScrollTime = millis();

        if (yPos < -(int)(currentText.length() * 8)) {
            active = false;
            return false;
        }
    }

    display.clearAll();

    // Draw only the letters that are (partly) on the screen
    for (unsigned int i = 0; i < currentText.length(); i++) {
        int charY = yPos + (i * 8);

        if (charY > -8 && charY < 32) {
            drawChar(display, 5, charY, currentText[i]);
        }
    }

    return true;
}

bool TextManager::isActive() {
    return active;
}
